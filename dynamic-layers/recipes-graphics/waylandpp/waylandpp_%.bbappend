# Copyright (C) 2020, Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

DEPENDS_remove += "mesa"

DEPENDS_append_class-target += "virtual/libgles2"
